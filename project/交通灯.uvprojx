# Keil uVision project 交通灯.uvprojx, settings and files
target 交通灯 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 交通灯 +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\project;..\startup;..\system\delay;..\system\sys;..\system\usart;..\STM32F10x_FWLib\inc;..\hardware\LED;..\hardware\KEY;..\hardware\LCD5110;..\hardware\SPI;..\hardware\BIGLED;..\hardware\DIGITALLED;..\hardware\UI;..\hardware\TRAFFIC;..\hardware\TIMER;..\hardware\EXTI
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group PROJ
    ./: stm32f10x_it.c system_stm32f10x.c main.c
  group STARTUP
    ../startup/: core_cm3.c startup_stm32f10x_hd.s
  group SYSTEM
    ../system/delay/: delay.c
    ../system/sys/: sys.c
    ../system/usart/: usart.c
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_exti.c
  group HARDWARE
    ../hardware/LED/: led.c
    ../hardware/KEY/: key.c
    ../hardware/LCD5110/: lcd5110.c
    ../hardware/SPI/: spi.c
    ../hardware/BIGLED/: bigled.c
    ../hardware/DIGITALLED/: digitalled.c
    ../hardware/UI/: ui.c
    ../hardware/TIMER/: timer.c
    ../hardware/EXTI/: exti.c
